# Keil uVision project Project.uvprojx, settings and files
target C30D_STM32F407_4WD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: C30D_4WD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: .\User;.\Hardware;.\Vendor\Device\Include;.\Vendor\CMSIS\Include;.\Vendor\Device\StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Vendor/Device/Source/ARM/: startup_stm32f40_41xxx.s
    ./Vendor/Device/Source/: system_stm32f4xx.c
  group StdPeriph
    ./Vendor/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group Hardware
    ./Hardware/: Board.c Board.h BoardConfig.h Timer.c Timer.h PWM.c PWM.h Motion.c Motor.c Motor.h Encoder.c Encoder.h PID.c PID.h ROSBridge.c ROSBridge.h OLED.c OLED.h OLED_Font.h
  group User
    ./User/: main.c stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_conf.h
